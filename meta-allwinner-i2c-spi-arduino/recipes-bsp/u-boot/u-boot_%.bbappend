SRC_URI += "file://allwinnerEnv.txt"